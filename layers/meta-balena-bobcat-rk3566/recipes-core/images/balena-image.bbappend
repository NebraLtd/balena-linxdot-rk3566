include balena-image.inc

BALENA_BOOT_PARTITION_FILES = " \
    idbloader.bin:/ \
    uboot.img:/ \
"
