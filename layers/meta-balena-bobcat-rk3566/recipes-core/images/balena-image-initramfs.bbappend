PACKAGE_INSTALL:remove:bobcat-rk3566 = " initramfs-module-recovery initramfs-module-migrate"
