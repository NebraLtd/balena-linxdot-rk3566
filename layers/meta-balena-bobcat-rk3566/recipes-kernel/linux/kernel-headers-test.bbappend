FILESEXTRAPATHS:append := "${THISDIR}/files:"
SRC_URI += "file://Dockerfile"
