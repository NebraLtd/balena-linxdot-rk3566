PACKAGE_INSTALL:remove:linxdot-rk3566 = " initramfs-module-recovery initramfs-module-migrate"
